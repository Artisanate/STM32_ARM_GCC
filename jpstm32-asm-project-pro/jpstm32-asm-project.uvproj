# Keil uVision project jpstm32-asm-project.uvproj, settings and files
target jpstm32-asm-project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: jpstm32-asm-project +hex
  c flags: Optim=1
  asm include: .\codes
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group codes
    ./codes/: init.s led.s common.s key.s usart.s tftlcd.s map.s main.c font.s
